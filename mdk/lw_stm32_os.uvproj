# Keil uVision project lw_stm32_os.uvproj, settings and files
target CAR_DB44_V1_0_20130315 (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CAR_DB44_V1_0_20130315 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL,STDIO, HSE_VALUE=12000000,CAR_DB44_V1_0_20130315
  c include: ..\core;..\..\code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\driver;..\app;..\app\ais;..\algorithm
  asm define: STM32F10X_CL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: app_usart.c main.c app_gprs.c tasks.c app_gps.c app_nmea.c app_lcd.c app_speed.c app_rtc.c print.c app_key.c app_voice.c app_lcd_menu.c app_beep.c app_network_data.c app_rfid.c app_hmc5883l_bmp085.c util.c app_watchdog.c app_zgb.c app_sys.c main_uart.c app_vc0706.c
  group core
    ../core/: board_init.c core.c system_stm32f10x.c core_.asm startup_stm32f10x_hd.s startup_stm32f10x_xl.s
    F:/STM32/aismbs/04系统实现/code_os/core/: startup_stm32f10x_cl.s
  group driver
    ../driver/: driv_usart.c stm32f10x_it.c core_cm3.c driv_systick.c driv_gprs.c driv_gps.c driv_lcd.c driv_speed.c driv_rtc.c driv_key.c driv_voice.c driv_beep.c driv_mfrc522.c driv_hmc5883l_bmp085.c driv_watchdog.c driv_zgb.c driv_vc0706.c
  group lib
    ../../code/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ais
    ../app/ais/: nmea0813.c proto.c
  group algorithm
    ../algorithm/: alg_loopback_buf.c alg_kalman.c
target DouLunJi_CAR_GBC_V1_2_130511 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DouLunJi_CAR_GBC_V1_2_130511 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,STDIO, HSE_VALUE=12000000,DouLunJi_CAR_GBC_V1_2_130511
  c include: as above
  asm define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target DouLunJi_AIS_BASE_STATION_V1_0_130513 (ARM-ADS)
  device: STM32F103RF STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80BFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DouLunJi_AIS_BASE_STATION_V1_0_130513 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL,STDIO, HSE_VALUE=12000000,DouLunJi_AIS_BASE_STATION_V1_0_130513
  c include: as above
  asm define: STM32F10X_XL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
target DouLunJi_CAR_TRUCK_1_3_140303 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: DouLunJi_CAR_TRUCK_1_3_140303 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,STDIO, HSE_VALUE=12000000,DouLunJi_CAR_TRUCK_1_3_140303
  c include: as above
  asm define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target CAR_TRUCK_1_5_140325 (ARM-ADS)
  device: STM32F103RF STMicroelectronics
  cpu: as above
  output: CAR_TRUCK_1_5_140325 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL,STDIO, HSE_VALUE=12000000,CAR_TRUCK_1_5_140325
  c include: as above
  asm define: STM32F10X_XL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
